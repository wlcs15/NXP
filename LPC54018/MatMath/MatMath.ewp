# IAR project MatMath.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: exceptionhelper.h main.cpp MainClass.cpp MainClass.h MatMath.cpp MatMath.h MatMathImpl.cpp MatMathImpl.h MatResult.cpp MatResult.h RectangularVectors.h RowColProdExecutable.cpp RowColProdExecutable.h RowColSumExecutable.cpp RowColSumExecutable.h
