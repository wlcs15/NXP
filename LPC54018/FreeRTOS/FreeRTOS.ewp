# IAR project FreeRTOS.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54018 NXP LPC54018
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; XIP_IMAGE; CPU_LPC54018; SDK_DEBUGCONSOLE=1; BOARD_USE_VIRTUALCOM; USB_STACK_FREERTOS; USB_STACK_USE_DEDICATED_RAM=1; BOARD_DEBUG_UART_TYPE=DEBUG_CONSOLE_DEVICE_TYPE_USBCDC; CPU_LPC54018JET180=1; USE_RTOS=1; FSL_RTOS_FREE_RTOS; A_LITTLE_ENDIAN; _DLIB_FILE_DESCRIPTOR=1; __little_endian__=1
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\..\Amazon_FreeRTOS\amazon-freertos\\freertos_kernel\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\drivers; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\cmsis_drivers; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\wifi_qca; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\wifi_qca\common_src\hcd; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\wifi_qca\common_src\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\wifi_qca\common_src\stack_common; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\wifi_qca\common_src\wmi; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\wifi_qca\custom_src\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\wifi_qca\custom_src\stack_custom; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\wifi_qca\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\wifi_qca\include\AR6002; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\wifi_qca\include\AR6002\hw2.0\hw; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\wifi_qca\port; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\wifi_qca\port\boards\lpc54018iotmodule\freertos; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\wifi_qca\port\boards\lpc54018iotmodule\freertos\gt202; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\wifi_qca\port\drivers\flexcomm_freertos; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\wifi_qca\port\env\freertos; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\usb\device; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\usb\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\middleware\usb\osa; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\utilities; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\utilities\io; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\utilities\log; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\utilities\str; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\CMSIS\Include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\boards\lpc54018iotmodule\aws_demos\config_files; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\boards\lpc54018iotmodule\aws_demos\application_code\nxp_code; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\freertos_kernel\portable\IAR\ARM_CM4F; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\network_manager; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\c_sdk\standard\common\include\private; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\c_sdk\standard\common\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\abstractions\platform\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\abstractions\platform\freertos\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\abstractions\secure_sockets\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\freertos_plus\standard\tls\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\freertos_plus\standard\crypto\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\abstractions\pkcs11\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\abstractions\wifi\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\demos\dev_mode_key_provisioning\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\freertos_plus\standard\utils\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\c_sdk\aws\defender\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\c_sdk\standard\mqtt\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\c_sdk\standard\serializer\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\c_sdk\aws\shadow\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\freertos_plus\aws\greengrass\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\abstractions\posix\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\boards\lpc54018iotmodule\ports\posix; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\freertos_plus\standard\freertos_plus_posix\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\3rdparty\mbedtls\include; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\3rdparty\mbedtls\include\mbedtls; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\abstractions\pkcs11\mbedtls; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\3rdparty\pkcs11; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\3rdparty\tinycbor; ..\..\..\Amazon_FreeRTOS\amazon-freertos\libraries\3rdparty\jsmn
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; XIP_IMAGE; MXL12835F; IMG_BAUDRATE=96000000
  AARM.AUserIncludes: $PROJ_DIR..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\boards\lpc54018iotmodule\aws_demos\config_files
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: XIP_IMAGE=1
  ILINK.IlinkIcfFile: ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\iar\LPC54018_spifi_flash_data.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\Amazon_FreeRTOS\amazon-freertos\vendors\nxp\LPC54018\iar\iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  group (top)
    ../../../Amazon_FreeRTOS/amazon-freertos/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../Amazon_FreeRTOS/amazon-freertos/freertos_kernel/portable/MemMang/: heap_4.c
    ./: main.cpp
    ../../../Amazon_FreeRTOS/amazon-freertos/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s portmacro.h
    ../../../Amazon_FreeRTOS/amazon-freertos/vendors/nxp/LPC54018/: system_LPC54018.c
